# Keil uVision project STM_DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM_DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER TM32F10X_MD
  c include: .\CMSIS;.\USER;.\FWlib\inc;.\HARDWARE;.\FATFS\src;.\FATFS\exfuns;.\TEXT;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ./CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c stm32f10x_it.c 说明.txt
  group APP
    ./APP/: systime.c mpu6050.c imu.c control.c rc.c motor.c maincom.c refreshled.c chuanPID.c
  group HARDWARE
    ./HARDWARE/: led.c SysTick.c myiic.c spi.c dma.c stmflash.c
  group FWlib
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
